# Keil uVision project elmo_lpc2478_keil.uvproj, settings and files
target elmo_lpc2478_keil (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: elmo_lpc2478_keil +hex
  c flags: Optim=1
  c define: __IN_CHIP
  c include: .\app;.\assemble;.\bsp;.\drivers;.\drivers\can;.\drivers\motor;.\drivers\timer;.\drivers\uart;.\drivers\ssi;.\drivers\norflash;.\drivers\I2C
  asm define: __IN_CHIP
  asm include: .\assemble
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\Scf\lpc2478_chipflash_keil.sct
  link misc: --entry 0x00000000
  group app
    ./app/: ISR.c main.h elmo_velocity.cpp filter.c miscellaneous.c
  group bsp
    ./bsp/: config.h target.c utility.c
  group drivers
    ./drivers/can/: lpc2400can.c
    ./drivers/motor/: SDO.c motor.c
    ./drivers/timer/: timer.c
    ./drivers/uart/: uart.c
    ./drivers/ssi/: ssi.c
    ./drivers/norflash/: norflash.c
  group assemble
    ./assemble/: LPC2400.h IRQ.s LPC2400.inc Startup.s vicControl.h vicControl.s
